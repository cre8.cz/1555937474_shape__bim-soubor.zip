Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-05-30T12:50:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 30 12:50:45 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{E906BDE0-18C1-48FE-84CA-D548B566AEFD}\ifc * Database version: 5507 * Database creation date: Mon May 30 12:50:45 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 30 12:50:45 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 30 12:50:45 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: Shape - H (38x38x45 cm / 14.96"x14.96"x17.71"), 2015_Table_Viccarbe_Shape:Shape - H (38x38x45 cm / 14.96"x14.96"x17.71"):133700
In: Nivel 1
Type - ElementType: Shape - H (38x38x45 cm / 14.96"x14.96"x17.71"); Material: Lacquered MDF
Type - Dimensions - Depth (inches): 14.96''; Depth (mm): 380 mm; Height (inches): 17.71''; Height (mm): 450 mm; Width (inches): 14.96''; Width (mm): 380 mm
Type - Identity Data - Bimetica: http://www.bimetica.com/; Collection: SHAPE; Content Revision Date: 26/05/2016; Created by: Bimetica Parametric Design Services, S.L.; Description: Shape is an occasional table available in two different versions. With its strong presence, almost like a small sculpture, its well-balanced proportions and attractive gloss, it has virtually become a cult piece.; Designer: JORGE PENSI; Essays UNE: http://www.viccarbe.com/archivos/viccarbe-shape-une-en-15372-08-79.pdf; General Dimensions (inches): 14.96''x14.96''x17.71''; General Dimensions (mm): 380x380x450mm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: MODEL H; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product URL: http://www.viccarbe.com/product.php?id=554deca94793eeb; Reference Code: SH-H; Series: -; Technical information: http://www.viccarbe.com/archivos/viccarbe-shape-en-48.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: Shape - H (38x38x45 cm / 14.96"x14.96"x17.71"); URL: http://www.viccarbe.com/; Warranty: 5 Years; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Base Material: Lacquered MDF; Materials - Woods: http://www.viccarbe.com/archivos/VICCARBE_woods_maderas.pdf
Type - Other - Category: Furniture; Family Name: 2015_Table_Viccarbe_Shape; Legs Situation (mm): 116.2 mm; Legs Situation 2 (mm): 51.5 mm; Radius (mm): 190 mm
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cantidades de mobiliario - Descripción de unidad: 2015_Table_Viccarbe_Shape: Shape - H (38x38x45 cm / 14.96"x14.96"x17.71"); Tipo: 2015_Table_Viccarbe_Shape: Shape - H (38x38x45 cm / 14.96"x14.96"x17.71"); Descripción: Shape is an occasional table available in two different versions. With its strong presence, almost like a small sculpture, its well-balanced proportions and attractive gloss, it has virtually become a cult piece.; Fabricante: VICCARBE; Modelo: MODEL H; URL: http://www.viccarbe.com/
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.382014 m2; Volume: 0.0510334 m3
Other - Family: 2015_Table_Viccarbe_Shape: Shape - H (38x38x45 cm / 14.96"x14.96"x17.71"); Family and Type: 2015_Table_Viccarbe_Shape: Shape - H (38x38x45 cm / 14.96"x14.96"x17.71"); Type: 2015_Table_Viccarbe_Shape: Shape - H (38x38x45 cm / 14.96"x14.96"x17.71"); Type Id: 2015_Table_Viccarbe_Shape: Shape - H (38x38x45 cm / 14.96"x14.96"x17.71")
Phasing - Phase Created: Fase 1
